## boards/shields/blue_numpad/Kconfig.defconfig
```kconfig
if SHIELD_BLUE_NUMPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Blue Numpad"

endif
```
